# Keil uVision project lianxiyi.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lianxiyi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Driver\ADC;.\Driver\Systick;.\Driver\Usart;.\Driver\BaseTime;.\Interface\key;.\Interface\Led;.\User;.\Common\Debug;.\StartUp;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./StartUp/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c app.c app.h
  group Common/Debug
    ./Common/Debug/: Common_Deebug.c Common_Deebug.h
  group Inf/led
    ./Interface/Led/: Int_Led.c Int_Led.h
  group Inf/key
    ./Interface/key/: Int_key.c Int_key.h
  group Dri/Basetime
    ./Driver/BaseTime/: Dri_Basetime.h Dri_Bsaetime.c
  group Dri/Systick
    ./Driver/Systick/: Dri_Systick.c Dri_Systick.h
  group Dri/Usart
    ./Driver/Usart/: Dri_usart.c Dri_usart.h
  group Dri/ADC
    ./Driver/ADC/: Dri_ADC.c Dri_ADC.h
